# Keil uVision project DYGLB.uvprojx, settings and files
target DYGLB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DYGLB +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\App;..\..\Bsp;..\..\Core;..\..\Dev;..\..\FWLIB\inc;..\..\Hardware\BSP;..\..\Hardware\BSP_Port;..\..\Middleware\alloc;..\..\Middleware\logger;..\..\Middleware\MultiTimer;..\..\Middleware\Ring-Buffer;..\..\User;..\..\Utilities;..\RTT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Core/: startup_stm32f40_41xxx.s
  group FWLIB
    ../../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c
  group APP
    ../../App/: app_config.h
  group DEV
    ../../Dev/: lc1258.h lc1258.c gda6641.h gda6641.c efuse.h efuse.c xca4001.h xca4001.c
  group BSP
    ../../Bsp/: board_map.h bsp_board.c bsp_board.h bsp_spi.c bsp_flash.c bsp_flash.h bsp_it.c bsp_it.h bsp_spi.h delay.c sys.c usart.c bsp_timer.c bsp_timer.h bsp_iwdg.c bsp_iwdg.h
  group User
    ../../User/: main.c system_stm32f4xx.c
  group Middleware
    ../../Middleware/alloc/: alloc.c
    ../../Middleware/MultiTimer/: MultiTimer.c softtimer.c
    ../../Middleware/Ring-Buffer/: ringbuffer_u8.c
  group Middleware/logger
    ../../Middleware/logger/: elog.c elog_buf.c elog_port.c elog_utils.c logger.c
  group Utilities
    ../../Utilities/: types_def.h
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
