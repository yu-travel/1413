# Keil uVision project DYGLB_U57.uvprojx, settings and files
target DYGLB_U57 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DYGLB_U57 +hex
  AfterMake: fromelf.exe --text -a -c -o "$L@L.dis" "#L"
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\Core;..\..\FWLIB\inc;..\..\Hardware\BSP;..\..\Hardware\BSP_Port;..\..\Middleware\alloc;..\..\Middleware\logger;..\..\Middleware\MultiTimer;..\..\Middleware\Ring-Buffer;..\..\System\delay;..\..\System\sys;..\..\System\usart;..\..\User;..\..\Utilities;..\RTT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Core/: startup_stm32f40_41xxx.s
  group FWLIB
    ../../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c
  group BSP
    ../../Hardware/BSP/: timer.c iwdg.c AD7606_Driver.c ad5542_driver.c periph_i2c.c
    ../../Hardware/BSP_Port/: at24cxx.c
  group System
    ../../System/delay/: delay.c
    ../../System/sys/: sys.c
    ../../System/usart/: usart.c
  group User
    ../../User/: main.c stm32f4xx_it.c system_stm32f4xx.c control_Dev.c control_Dev.h transf_jkkzb.c
  group Middleware
    ../../Middleware/alloc/: alloc.c
    ../../Middleware/MultiTimer/: MultiTimer.c softtimer.c
    ../../Middleware/Ring-Buffer/: ringbuffer_u8.c
  group Middleware/logger
    ../../Middleware/logger/: elog.c elog_buf.c elog_port.c elog_utils.c logger.c
  group Utilities
    ../../Utilities/: types_def.h
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
